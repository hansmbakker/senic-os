SUMMARY = "A library to work with OSRAM lightify."
HOMEPAGE = "https://github.com/aneumeier/python-lightify"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d2794c0df5b907fdace235a619d80314"

inherit setuptools3                                 
inherit pypi                                        
SRC_URI[md5sum] = "069a9dca52a6108f368e9cae6c23a604"

