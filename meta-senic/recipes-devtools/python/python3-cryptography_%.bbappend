export LDSHARED="${CCLD} -shared -pthread"
